# Keil uVision project at91sam7x256.uvproj, settings and files
target flash-SAM-ICE (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: at91sam7x256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: at91sam7x256-flash +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1
  c define: at91sam7x256 flash NOFPUT
  c misc: --gnu
  c include: ../../../at91lib/peripherals,../../basic-emac-uip-helloworld-project,../../../at91lib,../../../at91lib/components,../../../at91lib/utility,../../../external_libs/ethernet/uip/uip,../../../external_libs/ethernet/uip/lib,../../../external_libs/ethernet/uip/apps/hello-world,../../../external_libs/ethernet/uip/apps/dhcpc,../../../at91lib/boards/at91sam7x-ek
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/flash.sct
  link misc: --entry resetHandler
  group at91lib
    ../../../at91lib/components/ethernet/dm9161/: dm9161.c
    ../../../at91lib/peripherals/aic/: aic.c
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../../at91lib/peripherals/dbgu/: dbgu.c
    ../../../at91lib/peripherals/emac/: emac.c
    ../../../at91lib/peripherals/pio/: pio.c
    ../../../at91lib/peripherals/pmc/: pmc.c
    ../../../at91lib/peripherals/rstc/: rstc.c
    ../../../at91lib/peripherals/tc/: tc.c
    ../../../at91lib/peripherals/usart/: usart.c
    ../../../at91lib/boards/at91sam7x-ek/: board_lowlevel.c board_memories.c board_cstartup_keil.s
    ../../../at91lib/utility/: retarget.c
  group external_libs
    ../../../external_libs/ethernet/uip/apps/dhcpc/: dhcpc.c
    ../../../external_libs/ethernet/uip/apps/hello-world/: hello-world.c
    ../../../external_libs/ethernet/uip/lib/: memb.c
    ../../../external_libs/ethernet/uip/uip/: psock.c timer.c uip.c uip_arp.c
  group basic-emac-uip-helloworld-project
    ../../basic-emac-uip-helloworld-project/: clock-arch.c main.c tapdev.c
target sram-SAM-ICE (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: as above
  output: at91sam7x256-sram
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 sram NOFPUT
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/sram.sct
  link misc: --entry resetHandler
target flash-ULINK (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: as above
  output: at91sam7x256-flash
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 flash NOFPUT
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/flash.sct
  link misc: --entry resetHandler
target sram-ULINK (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: as above
  output: at91sam7x256-sram
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 sram NOFPUT
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/sram.sct
  link misc: --entry resetHandler
